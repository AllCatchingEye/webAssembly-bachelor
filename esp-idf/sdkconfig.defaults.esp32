## esp-idf/sdkconfig.defaults.esp32
```kconfig
# CONFIG_ESP32_MEMPROT_FEATURE is not set
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
```
